options:
  parameters:
    author: Felix Erckenbrecht
    copyright: '2021'
    description: Beautified version of a VOR Decoder built to solve CTS challenge 8.7 and 8.8 at RC3 2021
    generate_options: qt_gui
    id: VOR_Decoder
    output_language: python
    title: VOR Decoder
  states: {}

blocks:
- name: Decimation
  id: variable
  parameters:
    comment: |-
      Decimation
      Samplerate : Processing Rate
      (Integer)
    value: '64'
  states: {}
- name: baseband_hilbert_taps
  id: variable
  parameters:
    comment: |-
      Give enough taps to filter
      -30 Hz, while letting +30 Hz pass
    value: '4096'
  states: {}
- name: dec_rate
  id: variable
  parameters:
    comment: Processing Samplerate
    value: int(samp_rate/Decimation)
  states: {}
- name: declination
  id: variable_qtgui_range
  parameters:
    comment: |-
      Default value is set for
      Helgoland (VOR: DHE)
    label: Magnetic Declination
    orient: Qt.Horizontal
    start: '-45'
    step: '1'
    stop: '45'
    value: '3'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      Vary this delay to simulate
      other radial angles
    label: Additional Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: lowpass_300
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      Baseband Low Pass
      to block CW ID and noise
    cutoff_freq: '300'
    gain: '1.0'
    samp_rate: dec_rate
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Baseband samplerate
      Adjust for source
    value: '1920000'
  states: {}
- name: signal_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      (Offset) Frequency of
      VOR signal in baseband
    label: Signal Offset (kHz)
    orient: Qt.Horizontal
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '700'
  states: {}
- name: subcarrier_filter
  id: variable_high_pass_filter_taps
  parameters:
    comment: |-
      High Pass to isolate
      9960 Hz subcarrier
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: dec_rate
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: subcarrier_hilbert_taps
  id: variable
  parameters:
    comment: |-
      Not many taps required
      suppress -9960 Hz, pass +9960 Hz
    value: '65'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: signal_offset*1000
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio output for ID signal
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Filter CW ID frequency
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1300'
    low_cutoff_freq: '800'
    samp_rate: dec_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Undo previous phase-shift.
      Range is now: 0° ... 360°
    const: '[180, 180]'
    type: float
    vlen: '2'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      Get the (average)
      phase difference
      (range -pi ... +pi)
    vlen: '2'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: AM Demod
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    comment: |-
      Compensate Delay
      of Hilbert Transform
      in Subcarrier Channel
    delay: int(subcarrier_hilbert_taps/2)+delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/eligs/rc3_2021/challenge/challenge_flyinghigh_1920000_117Mhz.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Average the complex valued difference,
      also phase-shift by -Pi (-180°)
    length: '2048'
    max_iter: '2048'
    scale: '-0.027976454840372'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Subcarrier FM Demod
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      Obtain phase difference
      by multiplying conjugated
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert radians to °
    const: '[57.295779513082321, 57.295779513082321]'
    type: float
    vlen: '2'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Remove magnetic declination
      subtract a small phase shift
    const: cmath.exp(-2j*3.14159/360*declination)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '3000'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '3000'
    long_form: 'True'
    type: ff
  states: {}
- name: filter_delay_fc_1
  id: filter_delay_fc
  parameters:
    comment: |-
      Compensate Delay of
      Subcarrier Highpass
    taps: subcarrier_filter
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: subcarrier_filter
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lowpass_300
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lowpass_300
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: |-
      Make signal complex again
      (discard negative frequencies)
    num_taps: baseband_hilbert_taps
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    comment: |-
      Make signal complex again
      (discard negative frequencies)
    num_taps: baseband_hilbert_taps
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    comment: Make spectrum complex
    num_taps: subcarrier_hilbert_taps
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Signal Filter
      Center Frequency 0 Hz
      Bandwidth 12 kHz
    cutoff_freq: '12000'
    decim: Decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Radial (Magnetic North)
    label2: Radial (True North)
    max: '180'
    min: '-180'
    name: '"Radial"'
    nconnections: '2'
    type: float
    unit1: °
    unit2: °
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '12000'
    srate: dec_rate
    type: float
    ymax: '3.5'
    ymin: '-3.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_rate
    interp: '48000'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_complex_to_arg_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_complex_to_arg_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_delay_1, '0']
- [blocks_complex_to_mag_0, '0', hilbert_fc_1, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_1, '0', filter_delay_fc_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_streams_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_streams_to_vector_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_0, '1']
- [dc_blocker_xx_0, '0', hilbert_fc_0_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '1']
- [dc_blocker_xx_0_0, '0', hilbert_fc_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_time_sink_x_0, '0']
- [filter_delay_fc_1, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fir_filter_xxx_1, '0', dc_blocker_xx_0_0, '0']
- [fir_filter_xxx_1_0, '0', dc_blocker_xx_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [hilbert_fc_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [hilbert_fc_1, '0', fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
